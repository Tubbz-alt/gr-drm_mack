<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>DRMDebugFlowchart</value></param>
<param><key>author</key><value>Felix Wunsch</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Generic DRM Transmitter. For the MSC, only SM and EEP is implemented.</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>DRM Transmitter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SNR</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filename</value></param>
<param><key>value</key><value>'BER_'+str(SNR)+'.bin'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>path</value></param>
<param><key>value</key><value>'/mnt/hgfs/shared/DRM_Vinicius/'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable_drm_config</key>
<param><key>id</key><value>tp</value></param>
<param><key>audio_sample_rate</key><value>24000</value></param>
<param><key>comment</key><value>Before generating the flow graph, define the path 
to a 24 kHz wav-file and change the parameters 
of the UHD sink. Do not forget to set the correct 
audio_sample_rate.</value></param>
<param><key>long_interl</key><value>True</value></param>
<param><key>msc_mapping</key><value>1</value></param>
<param><key>msc_prot_level_2_16</key><value>1</value></param>
<param><key>msc_prot_level_2_64</key><value>0</value></param>
<param><key>RM</key><value>1</value></param>
<param><key>sdc_mapping</key><value>0</value></param>
<param><key>SO</key><value>3</value></param>
<param><key>station_label</key><value>"GNU Radio on DRM"</value></param>
<param><key>text_message</key><value>"This is a DRM transmission with GNU Radio"</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/user/papers/postZeroUnpadFlowchart.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>210</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0</value></param>
<param><key>file</key><value>/mnt/hgfs/shared/DRM_Vinicius/cellDemapping.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_0</value></param>
<param><key>file</key><value>/mnt/hgfs/shared/DRM_Vinicius/cellMapping.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>tp.ofdm().nfft()</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/mnt/hgfs/shared/DRM_Vinicius/in.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>m</key><value>tp.ofdm().nfft()</value></param>
<param><key>n</key><value>tp.ofdm().nfft()+(tp.ofdm().nfft()*tp.ofdm().cp_ratio_enum()/tp.ofdm().cp_ratio_denom())</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>comment</key><value>Prevent clipping</value></param>
<param><key>const</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>tp.ofdm().nfft()</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>tp.ofdm().nfft()</value></param>
</block>
<block>
<key>cell_mapping_cc</key>
<param><key>id</key><value>cell_mapping_cc_0</value></param>
<param><key>comment</key><value>Multiplex the three logical
channels and the pilot cells 
and create transmission frames.</value></param>
<param><key>tp</key><value>tp</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_1</value></param>
<param><key>cp_len</key><value>tp.ofdm().nfft()*tp.ofdm().cp_ratio_enum()/tp.ofdm().cp_ratio_denom()</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>input_size</key><value>tp.ofdm().nfft()</value></param>
<param><key>tagname</key><value></value></param>
</block>
<block>
<key>drm_generate_fac_b</key>
<param><key>id</key><value>drm_generate_fac_b_0</value></param>
<param><key>tp</key><value>tp</value></param>
</block>
<block>
<key>drm_generate_sdc_b</key>
<param><key>id</key><value>drm_generate_sdc_b_0</value></param>
<param><key>tp</key><value>tp</value></param>
</block>
<block>
<key>drm_receiver_cell_demapping</key>
<param><key>id</key><value>drm_receiver_cell_demapping_0</value></param>
<param><key>ncells</key><value>tp.ofdm().nfft()</value></param>
<param><key>nsymbols</key><value>1</value></param>
</block>
<block>
<key>drm_receiver_zero_unpad</key>
<param><key>id</key><value>drm_receiver_zero_unpad_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_len</key><value>tp.ofdm().nfft()</value></param>
<param><key>vector_len</key><value>210</value></param>
</block>
<block>
<key>drm_scrambler_bb</key>
<param><key>id</key><value>drm_scrambler_bb_0_0</value></param>
<param><key>block_len</key><value>tp.fac().L()</value></param>
</block>
<block>
<key>drm_scrambler_bb</key>
<param><key>id</key><value>drm_scrambler_bb_0_1</value></param>
<param><key>block_len</key><value>tp.sdc().L()</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>tp.ofdm().nfft()</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>tp.ofdm().nfft()</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>mlc_bc</key>
<param><key>id</key><value>mlc_bc_0</value></param>
<param><key>channel_type</key><value>"FAC"</value></param>
<param><key>comment</key><value>Apply channel coding
and interleaving</value></param>
<param><key>tp</key><value>tp</value></param>
</block>
<block>
<key>mlc_bc</key>
<param><key>id</key><value>mlc_bc_0_1</value></param>
<param><key>channel_type</key><value>"SDC"</value></param>
<param><key>tp</key><value>tp</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>qtgui_tab_widget_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label0</key><value>Time</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>sym_in</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>symbols</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>sym_out</value></param>
<param><key>stream_id</key><value>symbols</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>sym_out_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>symbols1</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>cell_mapping_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>drm_receiver_cell_demapping_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cell_mapping_cc_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cell_mapping_cc_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cell_mapping_cc_0</source_block_id><sink_block_id>sym_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_generate_fac_b_0</source_block_id><sink_block_id>drm_scrambler_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_generate_sdc_b_0</source_block_id><sink_block_id>drm_scrambler_bb_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_receiver_cell_demapping_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_receiver_zero_unpad_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_receiver_zero_unpad_0</source_block_id><sink_block_id>sym_out_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_scrambler_bb_0_0</source_block_id><sink_block_id>mlc_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_scrambler_bb_0_1</source_block_id><sink_block_id>mlc_bc_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>drm_receiver_zero_unpad_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mlc_bc_0</source_block_id><sink_block_id>cell_mapping_cc_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>mlc_bc_0_1</source_block_id><sink_block_id>cell_mapping_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>sym_in</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
