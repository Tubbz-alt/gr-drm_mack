<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>drm_transmitter</value></param>
<param><key>author</key><value>Felix Wunsch</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Generic DRM Transmitter. For the MSC, only SM and EEP is implemented.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>DRM Transmitter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>const1</value></param>
<param><key>value</key><value>digital.qam_constellation(M) </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable_drm_config</key>
<param><key>id</key><value>tp</value></param>
<param><key>audio_sample_rate</key><value>12000</value></param>
<param><key>comment</key><value>Before generating the flow graph, define the path 
to a 24 kHz wav-file and change the parameters 
of the UHD sink. Do not forget to set the correct 
audio_sample_rate.</value></param>
<param><key>long_interl</key><value>True</value></param>
<param><key>msc_mapping</key><value>2</value></param>
<param><key>msc_prot_level_2_16</key><value>1</value></param>
<param><key>msc_prot_level_2_64</key><value>0</value></param>
<param><key>RM</key><value>1</value></param>
<param><key>sdc_mapping</key><value>0</value></param>
<param><key>SO</key><value>3</value></param>
<param><key>station_label</key><value>"GNU Radio on DRM"</value></param>
<param><key>text_message</key><value>"This is a DRM transmission with GNU Radio"</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>10e-3</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/aluno/src/gr-drm_mack/examples/out.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>cell_mapping_cc</key>
<param><key>id</key><value>cell_mapping_cc_0</value></param>
<param><key>comment</key><value>Multiplex the three logical
channels and the pilot cells 
and create transmission frames.</value></param>
<param><key>tp</key><value>tp</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>const1.points()</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>const1.base()</value></param>
</block>
<block>
<key>drm_generate_fac_b</key>
<param><key>id</key><value>drm_generate_fac_b_0</value></param>
<param><key>tp</key><value>tp</value></param>
</block>
<block>
<key>drm_generate_sdc_b</key>
<param><key>id</key><value>drm_generate_sdc_b_0</value></param>
<param><key>tp</key><value>tp</value></param>
</block>
<block>
<key>drm_receiver_cell_demapping</key>
<param><key>id</key><value>drm_receiver_cell_demapping_0</value></param>
<param><key>ifft_length</key><value>1024</value></param>
</block>
<block>
<key>drm_scrambler_bb</key>
<param><key>id</key><value>drm_scrambler_bb_0_0</value></param>
<param><key>block_len</key><value>tp.fac().L()</value></param>
</block>
<block>
<key>drm_scrambler_bb</key>
<param><key>id</key><value>drm_scrambler_bb_0_1</value></param>
<param><key>block_len</key><value>tp.sdc().L()</value></param>
</block>
<block>
<key>mack_sdr_BERT</key>
<param><key>id</key><value>mack_sdr_BERT_0</value></param>
<param><key>Debug</key><value>1</value></param>
<param><key>NumBits</key><value>2</value></param>
<param><key>PackSize</key><value>1</value></param>
<param><key>SeqChoice</key><value>23</value></param>
<param><key>SyncMode</key><value>0</value></param>
</block>
<block>
<key>mack_sdr_PN_Gen</key>
<param><key>id</key><value>mack_sdr_PN_Gen_0</value></param>
<param><key>NumBits</key><value>2</value></param>
<param><key>PackSize</key><value>1</value></param>
<param><key>SeqChoice</key><value>23</value></param>
<param><key>SyncMode</key><value>0</value></param>
</block>
<block>
<key>mlc_bc</key>
<param><key>id</key><value>mlc_bc_0</value></param>
<param><key>channel_type</key><value>"FAC"</value></param>
<param><key>comment</key><value>Apply channel coding
and interleaving</value></param>
<param><key>tp</key><value>tp</value></param>
</block>
<block>
<key>mlc_bc</key>
<param><key>id</key><value>mlc_bc_0_1</value></param>
<param><key>channel_type</key><value>"SDC"</value></param>
<param><key>tp</key><value>tp</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>sym_out</value></param>
<param><key>stream_id</key><value>symbols</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>symbols</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>cell_mapping_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>drm_receiver_cell_demapping_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cell_mapping_cc_0</source_block_id><sink_block_id>sym_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>mack_sdr_BERT_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_generate_fac_b_0</source_block_id><sink_block_id>drm_scrambler_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_generate_sdc_b_0</source_block_id><sink_block_id>drm_scrambler_bb_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_receiver_cell_demapping_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_receiver_cell_demapping_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_scrambler_bb_0_0</source_block_id><sink_block_id>mlc_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_scrambler_bb_0_1</source_block_id><sink_block_id>mlc_bc_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mack_sdr_BERT_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mack_sdr_BERT_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mack_sdr_PN_Gen_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mlc_bc_0</source_block_id><sink_block_id>cell_mapping_cc_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>mlc_bc_0_1</source_block_id><sink_block_id>cell_mapping_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
